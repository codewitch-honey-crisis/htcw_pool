## zephyr/Kconfig
```kconfig
menu "htcw_pool configuration"
  config HTCW_POOL
    bool "Enable HTCW_POOL"
    default n
endmenu
```
